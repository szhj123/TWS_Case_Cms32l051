# Keil uVision project application.uvprojx, settings and files
target application (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMS32L051TS20 Cmsemicon
  pack: Cmsemicon.CMS32L051.1.3.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: application +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\CMSIS\Include;..\Device\Include;..\Device\Source;..\Driver\inc;..\User
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Startup
    ../Device/Source/ARM/: startup_CMS32L051.s
  group Cmsis
    ../Device/Source/: system_CMS32L051.c
  group Library
    ../Driver/src/: clk.c gpio.c adc.c intp.c
  group App
    ../User/: app_battery.c app_led.c main.c app_event.c app_key.c
  group Drv
    ../User/: drv_battery.c drv_led.c drv_task.c drv_timer.c drv_event.c drv_key.c drv_com.c
  group Hal
    ../User/: hal_interrupt.c hal_battery.c hal_led.c hal_task.c hal_timer.c hal_key.c hal_com.c hal_cms32l051.c
